# Start cores in EL2 mode
ATFW_OPT += ' RCAR_BL33_EXECUTION_EL=BL33_EL2'
